# IAR project CMSIS_Example_LPC17xx.ewp, settings and files
configuration MCB1700 (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCIncludePath2: ../../../CoreSupport; ../../../DeviceSupport/NXP/LPC17xx
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CMSIS_Example_LPC17xx.srec
  ILINK.IlinkOutputFile: CMSIS_Example.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: Abstract.txt main_LPC17xx.c startup_LPC17xx.s system_LPC17xx.c
    ../../../CoreSupport/: core_cm3.c
