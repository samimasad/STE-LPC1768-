# Keil uVision project Http_demo.uvproj, settings and files
target MCB1700 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Http_demo
  c flags: Optim=4
  c include: ..\..\core\cm3\
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group HTTP Files
    ./Web/: Web.inp index.htm network.cgi lcd.cgi leds.cgi system.cgi tcp.cgi language.cgi ad.cgi ad.cgx buttons.cgi buttons.cgx pg_header.inc pg_footer.inc xml_http.js
  group Source Files
    ./: HTTP_demo.c HTTP_CGI.c ADC.c KBD.c LED.c GLCD.c
    ./Web/: WEB.C
  group Configuration Files
    ./: Net_Config.c
  group Library
    C:/Keil/ARM/RV31/LIB/: TCP_CM3.lib
    ./: EMAC_LPC17xx.c
  group HAL Ethernet
    ./: EthDev_LPC17xx.c
  group CMSIS
    ./: startup_LPC17xx.s system_LPC17xx.c
  group Documentation
    ./: Abstract.txt
