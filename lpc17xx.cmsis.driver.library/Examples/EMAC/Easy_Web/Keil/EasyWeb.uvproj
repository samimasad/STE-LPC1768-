# Keil uVision project EasyWeb.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: EasyWeb +hex
  c flags: Optim=1
  c define: __BUILD_WITH_EXAMPLE__=1
  c include: ..\..\..\..\Core\CM3\CoreSupport;..\..\..\..\Drivers\include;..\..\Easy_Web;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Core Files
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Driver Files
    ../../../../Drivers/source/: lpc17xx_uart.c lpc17xx_clkpwr.c lpc17xx_emac.c lpc17xx_nvic.c lpc17xx_pinsel.c
  group Source Files
    ../: easyweb.c tcpip.c EMAC.c ADC.c Retarget.c debug_frmwrk.c
  group Documentation
    ../: Abstract.txt
