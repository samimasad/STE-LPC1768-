# IAR project uip_webserver.ewp, settings and files
configuration Flash (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __RAM_MODE__=0; __BUILD_WITH_EXAMPLE__=1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\apps\webserver; ..\lpc17xx_port; ..\uIP; ..; ..\..\..\..\Core\CM3\CoreSupport; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx; ..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx\startup\iar; ..\..\..\..\Drivers\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: UART.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\..\makesection\makerule\common\ldscript_irom_iar.ld
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS-CM3
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Common
    ../common/: printf-stdarg.c Serial.c
  group Drivers
    ../../../../Drivers/source/: lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_timer.c lpc17xx_uart.c lpc17xx_wdt.c
  group Port
    ../lpc17xx_port/: clock-arch.c debug_frmwrk.c emac.c main.c
  group Startup
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/iar/: startup_LPC17xx.s
  group uIP
    ../uip/: psock.c timer.c uip.c uip_arp.c
  group Webserver
    ../apps/webserver/: http-strings.c httpd-cgi.c httpd-fs.c httpd.c
