<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\i2s-4wire.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\RIT\Interrupt\EWARM\int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


