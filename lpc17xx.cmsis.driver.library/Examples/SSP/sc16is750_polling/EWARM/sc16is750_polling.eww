<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\sc16is750_polling.ewp</path>
  </project>
  <batchBuild/>
</workspace>


