# Keil uVision project UART.uvproj, settings and files
target FLASH (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: UART
  c flags: Optim=1
  c define: __RAM_MODE__=0
  c include: ..\..\..\Example;..\..\..\..\Core\CM3\DeviceSupport\NXP\LPC17xx;..\..\..\..\Drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Startup Code
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group CMSIS Source
    ../../: UartDev_LPC17xx_polling.c UartDev_LPC17xx.c
    ../../../../Core/CM3/CoreSupport/: core_cm3.c
    ../../../../Core/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Driver Source
    ../../../../Drivers/source/: lpc17xx_uart.c lpc17xx_clkpwr.c lpc17xx_libcfg_default.c lpc17xx_nvic.c lpc17xx_pinsel.c
  group Main
    ../../: Uart.c
  group Documentation
    ./: Abstract.txt
target RAM (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: as above
  output: UART
  c flags: Optim=1
  c define: __RAM_MODE__=1
  c include: as above
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x20000000 size 0x8000
